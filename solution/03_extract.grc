options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 315e6
  states: {}
- name: chan_width
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    type: real
    value: 315e6
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: select_mod
  id: variable_qtgui_chooser
  parameters:
    comment: |-
      Select FSK and OOK
      demod at runtime
      to see which 
      produces a digital
      waveform
    label0: OOK Demod
    label1: FSK Demod
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/symbol_rate
  states: {}
- name: squelch_level
  id: variable_qtgui_range
  parameters:
    comment: |-
      Adjust at runtime
      to eliminate FSK
      demod noise but 
      still allow signal 
      to pass
    start: '-100'
    step: '1'
    stop: '0'
    value: '-45'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 1/symbol_time
  states: {}
- name: symbol_time
  id: variable
  parameters:
    comment: |-
      Enter the correct
      value here
    value: '100e-6'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    comment: |-
      Adjust at runtime
      a value between the
      high and low OOK
      demod levels
    start: '0.001'
    step: '0.001'
    stop: '0.02'
    value: '0.01'
  states: {}
- name: working_samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1'
    gate: 'False'
    ramp: '0'
    threshold: squelch_level
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1 * threshold'
    type: float
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: quickstart_315M_1Msps.cf32
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: select_mod
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_1
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq-center_freq
    decim: int(samp_rate/working_samp_rate)
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, chan_width/2, chan_width/10)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Demod Out"'
    size: 1024*32
    srate: working_samp_rate
    tr_delay: '1e-3'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymin: '0'
  states: {}
- name: satellites_sync_to_pdu_0
  id: satellites_sync_to_pdu
  parameters:
    packlen: '145'
    sync: '"100011111100"'
    threshold: '0'
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_selector_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_selector_0, '0']
- [blocks_add_const_vxx_1, '0', digital_symbol_sync_xx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_selector_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_uchar_to_float_0_0_0, '0', blocks_add_const_vxx_1, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_binary_slicer_fb_1, '0', satellites_sync_to_pdu_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_pwr_squelch_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [satellites_sync_to_pdu_0, out, blocks_message_debug_0, log]

metadata:
  file_format: 1
  grc_version: 3.10.7.0
