options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: freq + samp_rate / 4
  states: {}
- name: chan_width
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    type: real
    value: 315.035e6
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: 250e3
  states: {state: disabled}
- name: preamble_str
  id: variable
  parameters:
    value: 16*"10" + "0010" + "1101" + "1101" + "0100"
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '5'
    stop: '55'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: working_samp_rate/symbol_rate
  states: {}
- name: squelch_level
  id: variable_qtgui_range
  parameters:
    start: '-100'
    step: '1'
    stop: '0'
    value: '-60'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 1.0/symbol_time
  states: {}
- name: symbol_time
  id: variable
  parameters:
    value: '4e-6'
  states: {}
- name: working_samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1'
    gate: 'False'
    ramp: '0'
    threshold: squelch_level
    type: complex
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz)
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: preamble_str
    tagname: preamble
    threshold: '0'
    type: byte
  states: {state: disabled}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: int(sps)
    sensitivity: '1.0'
  states: {state: disabled}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: center_freq
    freq_span: samp_rate
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq-center_freq
    decim: int(samp_rate/working_samp_rate)
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, chan_width/2, chan_width/10)
    type: ccc
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      this simple demod path allows
      for an estimate of the symbol
      timing, after which the GFSK
      Demod block can be used
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: working_samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: 1024*64
    srate: working_samp_rate
    tr_delay: 10*symbol_time
    tr_level: '0.5'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    marker1: '0'
    size: '1024'
    srate: symbol_rate
    tr_delay: symbol_time
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: satellites_sync_to_pdu_packed_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '64'
    sync: preamble_str
    threshold: '0'
  states: {state: disabled}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: rf_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:5565
    timeout: '100'
  states: {state: disabled}

connections:
- [analog_pwr_squelch_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_pwr_squelch_xx_0, '0', digital_gfsk_demod_0, '0']
- [analog_quadrature_demod_cf_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_uchar_to_float_0_0, '0']
- [digital_gfsk_demod_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_gfsk_demod_0, '0', satellites_sync_to_pdu_packed_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_pwr_squelch_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [satellites_sync_to_pdu_packed_0, out, zeromq_push_msg_sink_0, in]
- [uhd_usrp_source_1, '0', fosphor_qt_sink_c_0, '0']
- [uhd_usrp_source_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_1, '0', qtgui_freq_sink_x_0_0, '0']
- [uhd_usrp_source_1, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
